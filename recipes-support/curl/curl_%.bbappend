PACKAGECONFIG:${PN} += "zlib ipv6 ssl"
